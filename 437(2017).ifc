Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-21T17:43:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 21 17:43:10 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{AEA51509-F8F8-4D1B-A874-E377B7CE2664}\ifc * Database version: 5507 * Database creation date: Wed Aug 21 17:43:10 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 21 17:43:10 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 21 17:43:10 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 437 Hand shower set, 437(2017):437 Hand shower set:386922
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 85.8 mm; NominalHeight: 411.7 mm; NominalWidth: 123.4 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 437(2017); ConvergoRefNr: 0087-1909-0074-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 22/07/2019
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150080548; EN Standard: EN 1112; LVI Number: 6510226; NRF Number: 4205155; RSK Number: 8320160; VVS Number: 737596254
Type - Identity Data(Type) - Catalog Drawing URL: http://static.oras.com/catdrw/437; Dimension Drawing URL: http://static.oras.com/dimdrw/437; FDV Document URL: http://www.oras.com/datasheet/437/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/437; Group: Hand showers and shower sets; Long Marketing: Oras Hydractiva Style hand shower set including hand shower, wall bracket and 1500 mm shower hose. Hand shower with 3 spray modes: Sensitive (large & gently), Intense (powerful) and Pulse (massage). With limescale protection tecnology. Max. flow rate 15 l/min (3 bar). White spray face, shower head size 110 mm x 120 mm.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 437 Hand shower set; Name_en: 437 Hand shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 380 x 180 x 74; Package Weight: 0.81 kg; Product Code: 437; Product Datasheet: http://www.oras.com/datasheet/437/en; Product Family: Oras Hydractiva; Product Image URL: http://static.oras.com/image/437; Product URL: http://static.oras.com/437; Type Name: 437 Hand shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Flow Rate At 300kPa With Flow Controller: 0.00882867 m3/s; Hand Shower Size: 108 x 120 mm; Installation and Maintenance: http://static.oras.com/manual/437; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Shower holder;Hand shower;Shower Hose (1500 mm); Shower Spray: Sensitive;Intense;Massage; Shower Spray Number: 3 spray
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 437(2017); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 437; Name: 437 Hand shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 120x80x410 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 437; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 437 Hand shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0971869 m2; Volume: 0.00438343 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 437(2017): 437 Hand shower set; Family and Type: 437(2017): 437 Hand shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 437(2017): 437 Hand shower set; Type Id: 437(2017): 437 Hand shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
